## base_external/Config.in
```kconfig
source "$BR2_EXTERNAL_AESD_ASSIGNMENT_5_PATH/package/aesd-assignments/Config.in"
```
